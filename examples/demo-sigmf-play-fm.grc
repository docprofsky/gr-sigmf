<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>demo_sigmf_play_fm</value></param>
<param><key>author</key><value>Scott</value></param>
<param><key>catch_exceptions</key><value>1</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Demo: SigMF FM Annotation Player</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decimation</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>int(48e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_decimation</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>audio_decimation</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>filter_decimation</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, 80000, 20000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_1</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>audio_rate / (samp_rate / (filter_decimation * audio_decimation))</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>98e6</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-50</value></param>
<param><key>int_min</key><value>-80</value></param>
<param><key>name</key><value>"Raw"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1/30.</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_1_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>98e6</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>-50</value></param>
<param><key>int_min</key><value>-80</value></param>
<param><key>name</key><value>"Extracted"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1/30.</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>sigmf_extract_annotation</key>
<param><key>id</key><value>sigmf_extract_annotation_0</value></param>
<param><key>retune</key><value>True</value></param>
</block>
<block>
<key>sigmf_source</key>
<param><key>id</key><value>sigmf_source_0</value></param>
<param><key>filename</key><value>/tmp/fm-band.sigmf-data</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_extract_annotation_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_extract_annotation_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_source_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>meta</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sigmf_source_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sigmf_source_0</source_block_id><sink_block_id>sigmf_extract_annotation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
